# Keil uVision project baseflight.uvproj, settings and files
target STM32 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: baseflight +hex
  c flags: Optim=1 wLevel=2
  c define: STMF30X,USE_STDPERIPH_DRIVER,NAZEPRO
  c misc: --c99 --gnu
  c include: .\lib\STM32F30x_StdPeriph_Driver\inc;.\lib\STM32_USB-FS-Device_Driver\inc;.\lib\CMSIS\Device\ST\STM32F30x\Include;.\lib\CMSIS\Include;.\src;.\src\vcp
  library: MicroLIB
  group App
    ./src/: utils_math.c align.c buzzer.c cli.c config.c gps.c imu.c main.c mixer.c msp.c mw.c rxmsp.c rxsbus.c rxspektrum.c rxsumd.c sensors.c telemetry_common.c telemetry_frsky.c telemetry_hott.c
  group Drivers
    ./src/drv/: usb.c adc_stm32f30x.c crc.c gpio_stm32f30x.c i2c_soft.c i2c_stm32f30x.c pwm.c serial.c spi_stm32f30x.c timer.c uart.c uart_stm32f30x.c board_stm32f30x.c
  group Sensors
    ./src/sensors/: spi_ms5611.c i2c_adxl345.c i2c_bma280.c i2c_bmp085.c i2c_hmc5883l.c i2c_l3g4200d.c i2c_mma845x.c i2c_mpu3050.c i2c_mpu6050.c i2c_ms5611.c pwm_hcsr04.c spi_hmc5983.c spi_mpu6000.c
  group System
    ./src/: printf.c
    ./src/vcp/: usb_pwr.c hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
    ./src/startup/: startup_stm32f30x.s
    ./lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
    ./lib/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
    ./lib/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
target STM32-Release (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: baseflight +hex
  c flags: Optim=4 wLevel=2
  c define: STM32F30X,USE_STDPERIPH_DRIVER,NAZEPRO
  c misc: --c99 --gnu
  c include: .\lib\STM32_USB-FS-Device_Driver\inc;.\lib\STM32F30x_StdPeriph_Driver\inc;.\src;.\src\drv;.\src\vcp;.\lib\CMSIS\Device\ST\STM32F30x\Include;.\lib\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
